options:
  parameters:
    author: lingo@de-mes.nl
    generate_options: qt_gui
    id: hld_example
    output_language: python
    title: hld example
  states: {}

blocks:
- name: azimuth
  id: variable_qtgui_label
  parameters:
    gui_hint: controls@0
    label: Azimuth
    type: real
    value: '0.00'
  states: {}
- name: baseband
  id: variable_qtgui_label
  parameters:
    gui_hint: controls@0
    label: Baseband
    type: int
    value: '144000000'
  states: {}
- name: decimation
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0
    label: Decimation
    rangeType: int
    start: '1'
    step: '1'
    stop: '512'
    value: '5'
    widget: counter
  states: {}
- name: device_arguments
  id: variable
  parameters:
    value: '"rtl_tcp=192.168.178.4:1234"'
  states: {}
- name: elevation
  id: variable_qtgui_label
  parameters:
    gui_hint: controls@0
    label: Elevation
    type: real
    value: '0.0'
  states: {}
- name: freq
  id: variable_qtgui_label
  parameters:
    gui_hint: controls@0
    label: Frequency
    type: int
    value: '144000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: controls@0
    label: Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '42'
    widget: counter
  states: {}
- name: offset
  id: variable_qtgui_label
  parameters:
    gui_hint: controls@0
    label: Offset
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: controls@0
    label: Sample rate
    labels: '[]'
    num_opts: '0'
    options: '[240000, 300000, 960000, 1152000, 1200000, 1440000, 1600000, 1800000, 1920000, 2400000, 2880000, 3200000]'
    type: int
    value: '240000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: controls
    num_tabs: '1'
  states: {}
- name: hld_bursttrigger_0
  id: hld_bursttrigger
  parameters:
    azimuth_max: '540.0'
    azimuth_min: '-180.0'
    elevation_max: '210.0'
    elevation_min: '-20.0'
  states: {}
- name: hld_rigctld_0
  id: hld_rigctld
  parameters:
    addr: localhost
    baseband_var: baseband
    baseband_width: samp_rate
    freq_var: freq
    offset_var: offset
    port: '7356'
  states: {}
- name: hld_rotctld_0
  id: hld_rotctld
  parameters:
    addr: localhost
    azimuth_var: azimuth
    elevation_var: elevation
    port: '4533'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: freq
    fftsize: '1024'
    tr_level: '0'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '3'
    fc: baseband
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    alias: rtlsdr_source
    args: device_arguments
    bb_gain0: '20'
    freq0: baseband
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_burst_tagger_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_burst_tagger_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [hld_bursttrigger_0, '0', blocks_burst_tagger_0, '1']
- [hld_bursttrigger_0, state, blocks_message_debug_0, print]
- [hld_rigctld_0, acquired, hld_bursttrigger_0, acquired]
- [hld_rotctld_0, azimuth, hld_bursttrigger_0, azimuth]
- [hld_rotctld_0, elevation, hld_bursttrigger_0, elevation]
- [rational_resampler_xxx_0, '0', blocks_burst_tagger_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
